# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\User;.\Library;.\System;.\Hardware;.\CJSON;.\DSPlib\Include;.\BSP\stm32f103c8t6_minidev
  memory RVCT4: ROM 0x8000000 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: MyFLASH.c MyFLASH.h Store.c Store.h Delay.c Delay.h Timer.c Timer.h MYIWD.c MYIWD.h MyRTC.c MyRTC.h
  group Hardware
    ./Hardware/: OLED.c OLED.h OLED_Fonts.c OLED_Fonts.h OLED_UI.c OLED_UI.h OLED_UI_Driver.c OLED_UI_Driver.h OLED_UI_MenuData.c OLED_UI_MenuData.h base64.c base64.h esp8266.c esp8266.h hmac_sha1.c hmac_sha1.h MqttKit.c MqttKit.h onenet.c onenet.h DHT11.c DHT11.h PMS7003.c PMS7003.h Alarm.c Alarm.h XM7903.c XM7903.h CRC16.c CRC16.h ErrorWarningLog.c ErrorWarningLog.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h project_secrets.c project_secrets.h
  group CJSON
    ./CJSON/: cJSON.c cJSON.h
  group BSP
    ./BSP/stm32f103c8t6_minidev/: bsp_oled.c bsp_config.h bsp_oled.h bsp_usart.c bsp_usart.h bsp_pms7003.c bsp_pms7003.h bsp_xm7903.c bsp_xm7903.h
